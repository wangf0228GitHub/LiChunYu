# Keil uVision project stm32key_5833.uvprojx, settings and files
target STM32L412CBUx (ARM-ADS)
  device: STM32L412CBUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00008000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32key_5833
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group :STM32CubeMX:Common Sources
    ./Inc/: gpio.h tim.h usb_device.h usbd_conf.h usbd_desc.h usbd_custom_hid_if.h stm32l4xx_it.h stm32l4xx_hal_conf.h main.h
    ./Src/: gpio.c tim.c usb_device.c usbd_conf.c usbd_desc.c usbd_custom_hid_if.c stm32l4xx_it.c stm32l4xx_hal_msp.c main.c
