# Keil uVision project stm32key_5833.uvprojx, settings and files
target stm32key_5833 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L412CBUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32key_5833 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L412xx,KEIL
  c include: ../../Inc;  ../../Drivers/STM32L4xx_HAL_Driver/Inc;  ../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;  ../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;  ../../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;  ../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;  ../../Drivers/CMSIS/Include;  ..\..\wf;  ..\..\..\..\WF_Device\stm32;  ..\..\..\..\WF_Device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l412xx.s
  group wflib
    ../../../../WF_Device/stm32/: wfSys.c
    ../../../../WF_Device/: lcyHash.c lcyIRDecode.c SimSPI.c SPIROM.c Verify.c
  group wf
    ../../wf/: AS3933.c ATA5833.c ButtonProc.c Function.c OnCarProc.c Variables.c USBInteraction.c
  group Application/User
    ../../Src/: main.c gpio.c tim.c usb_device.c usbd_conf.c usbd_desc.c usbd_custom_hid_if.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
software components: CMSIS:CORE 5.0.0
