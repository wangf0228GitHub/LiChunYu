# Keil uVision project STM32F4Test.uvprojx, settings and files
target STM32F4Test (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F4Test +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;              ../Drivers/STM32F4xx_HAL_Driver/Inc;              ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;              ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;              ../Drivers/CMSIS/Include;              ../wf
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: can.c gpio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c tim.c
    ../wf/: CP1616_Client.c ESLProc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.1.0
